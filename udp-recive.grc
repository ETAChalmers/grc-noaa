<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>udp-recive</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>IF_gain</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NOAA15</value></param>
<param><key>value</key><value>0.11375e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NOAA18</value></param>
<param><key>value</key><value>0.40625e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NOAA19</value></param>
<param><key>value</key><value>-0.40625e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Out_samprate</value></param>
<param><key>value</key><value>samp_rate/dec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_gain</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>34e3</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>channel_nr</value></param>
<param><key>block_id</key><value>Probe_channel</value></param>
<param><key>function_name</key><value>get_value</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_0</value></param>
<param><key>value</key><value>137.50625e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>850e3</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA15_fall</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq_0+NOAA15</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA15 (stream 2)"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA18_fall</value></param>
<param><key>bw</key><value>Out_samprate</value></param>
<param><key>fc</key><value>freq_0+NOAA18</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA18 (stream 1)"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA19_fall</value></param>
<param><key>bw</key><value>Out_samprate</value></param>
<param><key>fc</key><value>freq_0+NOAA19</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA19 (stream 0)"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>1</value></param>
<param><key>quad_rate</key><value>bandwidth</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>channel_nr</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>3</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_1</value></param>
</block>
<block>
<key>blocks_endian_swap</key>
<param><key>id</key><value>blocks_endian_swap_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>s16</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>500</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_1</value></param>
<param><key>length</key><value>4000</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_2</value></param>
<param><key>length</key><value>4000</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_2_0</value></param>
<param><key>length</key><value>4000</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>localhost</value></param>
<param><key>port</key><value>7355</value></param>
<param><key>type</key><value>float</value></param>
<param><key>psize</key><value>1225</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1231</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0_1</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1230</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0_2</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1232</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/david/Music/foobar</value></param>
<param><key>samp_rate</key><value>11025</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe_channel</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>short</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Selected channel"</value></param>
<param><key>update_time</key><value>0.1</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>34000</value></param>
<param><key>interp</key><value>11025</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>Channel</value></param>
</block>
<block>
<key>vocoder_g721_encode_sb</key>
<param><key>id</key><value>vocoder_g721_encode_sb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>probe_channel</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_moving_average_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_1</source_block_id><sink_block_id>blocks_moving_average_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_endian_swap_0</source_block_id><sink_block_id>vocoder_g721_encode_sb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_endian_swap_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_1</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_2</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_2_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>NOAA19_fall</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_1</source_block_id><sink_block_id>NOAA18_fall</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_1</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_2</source_block_id><sink_block_id>NOAA15_fall</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_2</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_2</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_encode_sb_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
