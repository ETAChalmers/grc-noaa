<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>udp-recive</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>IF_gain</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NOAA15</value></param>
<param><key>value</key><value>0.11375e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NOAA18</value></param>
<param><key>value</key><value>0.40625e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>NOAA19</value></param>
<param><key>value</key><value>-0.40625e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Out_samprate</value></param>
<param><key>value</key><value>samp_rate/dec</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_gain</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>34e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dec</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_0</value></param>
<param><key>value</key><value>137.50625e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>850e3</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA15_fall</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq_0+NOAA15</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA15"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA15_fall_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq_0+NOAA15</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA15"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA18_fall</value></param>
<param><key>bw</key><value>Out_samprate</value></param>
<param><key>fc</key><value>freq_0+NOAA18</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA18"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA18_fall_0</value></param>
<param><key>bw</key><value>Out_samprate</value></param>
<param><key>fc</key><value>freq_0+NOAA18</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA18"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA19_fall</value></param>
<param><key>bw</key><value>Out_samprate</value></param>
<param><key>fc</key><value>freq_0+NOAA19</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA19"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>NOAA19_fall_0</value></param>
<param><key>bw</key><value>Out_samprate</value></param>
<param><key>fc</key><value>freq_0+NOAA19</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"NOAA19"</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-NOAA19</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-NOAA18</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>-NOAA15</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>base</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq_0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>name</key><value>base</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1231</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1231</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0_1</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1230</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0_2</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1232</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>bandwidth</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>3e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>bandwidth</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>3e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1</value></param>
<param><key>cutoff_freq</key><value>bandwidth</value></param>
<param><key>decim</key><value>dec</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>3e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>NOAA19_fall</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_0</source_block_id><sink_block_id>base</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_1</source_block_id><sink_block_id>NOAA18_fall</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0_2</source_block_id><sink_block_id>NOAA15_fall</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>NOAA19_fall_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>NOAA18_fall_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>NOAA15_fall_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
