options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: udp-recive
  states: {}

blocks:
- name: IF_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: NOAA15
  id: variable
  parameters:
    value: 0.11375e6
  states: {}
- name: NOAA18
  id: variable
  parameters:
    value: 0.40625e6
  states: {}
- name: NOAA19
  id: variable
  parameters:
    value: '-0.40625e6'
  states: {}
- name: Out_samprate
  id: variable
  parameters:
    value: samp_rate/dec
  states: {}
- name: RF_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: 34e3
  states: {}
- name: dec
  id: variable
  parameters:
    value: '25'
  states: {}
- name: freq_0
  id: variable
  parameters:
    value: 137.50625e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: NOAA15_fall
  id: qtgui_sink_x
  parameters:
    bw: Out_samprate
    fc: freq_0+NOAA15
    fftsize: '1024'
    name: '"NOAA15 (stream 2)"'
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: NOAA18_fall
  id: qtgui_sink_x
  parameters:
    bw: Out_samprate
    fc: freq_0+NOAA18
    fftsize: '1024'
    name: '"NOAA18 (stream 1)"'
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: NOAA19_fall
  id: qtgui_sink_x
  parameters:
    bw: Out_samprate
    fc: freq_0+NOAA19
    fftsize: '1024'
    name: '"NOAA19 (stream 0)"'
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: bandwidth
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '3'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_1
  id: blocks_moving_average_xx
  parameters:
    length: '4000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_2
  id: blocks_moving_average_xx
  parameters:
    length: '4000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_2_0
  id: blocks_moving_average_xx
  parameters:
    length: '4000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.5'
    init: '0'
    low: '-0.5'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '1.5'
    init: '0'
    low: '0.5'
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: '2.5'
    init: '0'
    low: '1.5'
  states: {}
- name: blocks_threshold_ff_0_2
  id: blocks_threshold_ff
  parameters:
    high: '1.5'
    init: '0'
    low: '0.5'
  states: {}
- name: blocks_threshold_ff_0_2_0
  id: blocks_threshold_ff
  parameters:
    high: '1.5'
    init: '0'
    low: '0.5'
  states: {}
- name: blocks_threshold_ff_0_2_0_0
  id: blocks_threshold_ff
  parameters:
    high: '1.5'
    init: '0'
    low: '0.5'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: localhost
    port: '7355'
    psize: '1225'
    type: float
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    maxoutbuf: '1472'
    port: '1231'
    psize: '3000'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_source_0_1
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    maxoutbuf: '1472'
    port: '1230'
    psize: '3000'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_source_0_2
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    maxoutbuf: '1472'
    port: '1232'
    psize: '3000'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /home/david/Music/foobar
    samp_rate: '11025'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '2'
    min: '0'
    name: '"Selected channel"'
    type: short
    update_time: '0.1'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '2'
    min: '0'
    name: '"channel0"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '2'
    min: '0'
    name: '"channel1"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '2'
    min: '0'
    name: channel2
    type: float
    update_time: '0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '34000'
    interp: '11025'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: ccf
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Channel
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Channel0
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Channel1
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Channel2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Channel
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Channel0
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Channel1
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: Channel2
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_rcv_0, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_1, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_2, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_moving_average_2_0, '0']
- [blocks_float_to_complex_1, '0', virtual_sink_1, '0']
- [blocks_float_to_complex_1_0, '0', virtual_sink_1_0, '0']
- [blocks_float_to_complex_1_1, '0', virtual_sink_1_0_0, '0']
- [blocks_moving_average_1, '0', blocks_streams_to_vector_0, '0']
- [blocks_moving_average_2, '0', blocks_streams_to_vector_0, '1']
- [blocks_moving_average_2_0, '0', blocks_streams_to_vector_0, '2']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_short_to_float_0, '0', virtual_sink_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_argmax_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_threshold_ff_0_2, '0']
- [blocks_threshold_ff_0_0, '0', blocks_threshold_ff_0_2_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_threshold_ff_0_2_0_0, '0']
- [blocks_threshold_ff_0_2, '0', blocks_float_to_complex_1, '0']
- [blocks_threshold_ff_0_2, '0', qtgui_number_sink_0_0, '0']
- [blocks_threshold_ff_0_2_0, '0', blocks_float_to_complex_1_0, '0']
- [blocks_threshold_ff_0_2_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_threshold_ff_0_2_0_0, '0', blocks_float_to_complex_1_1, '0']
- [blocks_threshold_ff_0_2_0_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_udp_source_0, '0', NOAA19_fall, '0']
- [blocks_udp_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_udp_source_0, '0', rational_resampler_xxx_1, '0']
- [blocks_udp_source_0_1, '0', NOAA18_fall, '0']
- [blocks_udp_source_0_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_udp_source_0_1, '0', rational_resampler_xxx_1_0, '0']
- [blocks_udp_source_0_2, '0', NOAA15_fall, '0']
- [blocks_udp_source_0_2, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_udp_source_0_2, '0', rational_resampler_xxx_1_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_udp_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [rational_resampler_xxx_1_0_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [virtual_source_0, '0', blocks_threshold_ff_0, '0']
- [virtual_source_0, '0', blocks_threshold_ff_0_0, '0']
- [virtual_source_0, '0', blocks_threshold_ff_0_1, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0, '1']
- [virtual_source_1_0, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_1_0_0, '0', blocks_multiply_xx_0_0_0, '1']

metadata:
  file_format: 1
