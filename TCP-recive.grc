options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 850e3/30
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '1230'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_source_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '1231'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: blocks_udp_source_0_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '1232'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_udp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_udp_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_udp_source_0_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']

metadata:
  file_format: 1
